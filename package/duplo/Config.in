## package/duplo/Config.in
```kconfig
config BR2_PACKAGE_DUPLO
	bool "duplo"
	help
	  Control a Duplo 9203 Remote Control Car Kit
          with a Nintendo Wii Nunchuk via LIRC
```
